deltask do_package_qa

DEFAULT_PREFERENCE = "-1"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/\
${LICENSE};md5=3775480a712fc46a69647678acb234cb"

SRC_URI = ""

do_fetch_prepend () {
    import os
    cmd = "cd ${WORKSPACE}/poky/meta-qti-bsp/recipes-multimedia/gstreamer && rm -rf files gst-player gstreamer1.0 gstreamer1.0-libav gstreamer1.0-plugins-base gstreamer1.0-plugins-good gstreamer1.0-rtsp-server gstreamer1.0-vaapi && mkdir files gst-player gstreamer1.0 gstreamer1.0-libav gstreamer1.0-plugins-base gstreamer1.0-plugins-good gstreamer1.0-rtsp-server gstreamer1.0-vaapi  && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0/deterministic-unwind.patch?h=yoctoproject.org/master -O gstreamer1.0/deterministic-unwind.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/files/0001-introspection.m4-prefix-pkgconfig-paths-with-PKG_CON.patch?h=yoctoproject.org/master -O files/0001-introspection.m4-prefix-pkgconfig-paths-with-PKG_CON.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gst-player/0001-gtk-play-provide-similar-behaviour-for-quit-and-clos.patch?h=yoctoproject.org/master -O gst-player/0001-gtk-play-provide-similar-behaviour-for-quit-and-clos.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gst-player/Add-error-signal-emission-for-missing-plugins.patch?h=yoctoproject.org/master -O gst-player/Add-error-signal-emission-for-missing-plugins.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gst-player/Fix-pause-play.patch?h=yoctoproject.org/master -O gst-player/Fix-pause-play.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gst-player/filechooser.patch?h=yoctoproject.org/master -O gst-player/filechooser.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gst-player/gst-player.desktop?h=yoctoproject.org/master -O gst-player/gst-player.desktop && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-libav/0001-Disable-yasm-for-libav-when-disable-yasm.patch?h=yoctoproject.org/master -O gstreamer1.0-libav/0001-Disable-yasm-for-libav-when-disable-yasm.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-libav/mips64_cpu_detection.patch?h=yoctoproject.org/master -O gstreamer1.0-libav/mips64_cpu_detection.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-libav/workaround-to-build-gst-libav-for-i586-with-gcc.patch?h=yoctoproject.org/master -O gstreamer1.0-libav/workaround-to-build-gst-libav-for-i586-with-gcc.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-base/0001-Makefile.am-don-t-hardcode-libtool-name-when-running.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-base/0001-Makefile.am-don-t-hardcode-libtool-name-when-running.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-base/0002-Makefile.am-prefix-calls-to-pkg-config-with-PKG_CONF.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-base/0002-Makefile.am-prefix-calls-to-pkg-config-with-PKG_CONF.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-base/0003-riff-add-missing-include-directories-when-calling-in.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-base/0003-riff-add-missing-include-directories-when-calling-in.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-base/0003-ssaparse-enhance-SSA-text-lines-parsing.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-base/0003-ssaparse-enhance-SSA-text-lines-parsing.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-base/0004-rtsp-drop-incorrect-reference-to-gstreamer-sdp-in-Ma.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-base/0004-rtsp-drop-incorrect-reference-to-gstreamer-sdp-in-Ma.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-base/0004-subparse-set-need_segment-after-sink-pad-received-GS.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-base/0004-subparse-set-need_segment-after-sink-pad-received-GS.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-base/encodebin-Need-more-buffers-in-output-queue-for-bett.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-base/encodebin-Need-more-buffers-in-output-queue-for-bett.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-base/get-caps-from-src-pad-when-query-caps.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-base/get-caps-from-src-pad-when-query-caps.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-base/make-gio_unix_2_0-dependency-configurable.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-base/make-gio_unix_2_0-dependency-configurable.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-good/0001-gstrtpmp4gpay-set-dafault-value-for-MPEG4-without-co.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-good/0001-gstrtpmp4gpay-set-dafault-value-for-MPEG4-without-co.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-good/avoid-including-sys-poll.h-directly.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-good/avoid-including-sys-poll.h-directly.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-good/ensure-valid-sentinel-for-gst_structure_get.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-good/ensure-valid-sentinel-for-gst_structure_get.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-plugins-good/qtdemux-free-seqh-after-calling-qtdemux_parse_svq3_s.patch?h=yoctoproject.org/master -O gstreamer1.0-plugins-good/qtdemux-free-seqh-after-calling-qtdemux_parse_svq3_s.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-rtsp-server/0001-Don-t-hardcode-libtool-name-when-using-introspection.patch?h=yoctoproject.org/master -O gstreamer1.0-rtsp-server/0001-Don-t-hardcode-libtool-name-when-using-introspection.patch && wget https://source.codeaurora.org/quic/qyocto/oss/poky/plain/meta/recipes-multimedia/gstreamer/gstreamer1.0-vaapi/install-tests.patch?h=yoctoproject.org/master -O gstreamer1.0-vaapi/install-tests.patch"

    os.system(cmd)
}
